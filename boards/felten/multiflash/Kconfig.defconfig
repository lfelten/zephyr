## boards/felten/multiflash/board.yml
```yaml
board:
  name: multiflash
  full_name: "multiflash"
  vendor: felten
  socs:
  - name: nrf52833
```
